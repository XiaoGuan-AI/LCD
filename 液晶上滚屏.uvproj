# Keil uVision project 液晶上滚屏.uvproj, settings and files
target 液晶上滚屏 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 液晶上滚屏 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: G:\danpianji\keil\C51\INC;G:\danpianji\keil\C51\INC\Atmel
  group main
    ./: main.c
